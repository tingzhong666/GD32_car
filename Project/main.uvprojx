# Keil uVision project main.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F470ZG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.1.0
  cpu: IRAM(0x20000000,0x070000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: main +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: GD32F470
  c include: ..\User;..\Firmware\CMSIS;..\Firmware\CMSIS\GD\GD32F4xx\Include;..\Firmware\GD32F4xx_standard_peripheral\Include;..\Hardware
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x70000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Firmware
    ../Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_rcu.c gd32f4xx_gpio.c gd32f4xx_timer.c gd32f4xx_usart.c gd32f4xx_dma.c gd32f4xx_misc.c gd32f4xx_exti.c
  group BSP
    ../Hardware/: led.c test.c pwm.c uart.c tracking.c ultrasonic.c
  group User
    ../User/: gd32f4xx_it.c main.c systick.c car.c bluetooth.c auto_track.c obstacleVoidance.c
  group CMSIS
    ../Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
    ../Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450_470.s
